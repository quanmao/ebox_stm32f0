# Keil uVision project First.uvprojx, settings and files
target STM32F0 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F030F4 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.0.3
  cpu: IROM(0x08000000,0x4000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: First
  c flags: Optim=4 OneElfS=1
  c define: STM32F072xB USE_HAL_DRIVER
  c include: ..\Libraries\CMSIS\Device\ST\STM32F0xx\Include;..\Libraries\STM32F0xx_HAL_Driver\Inc;..\User;..\Driver;..\fat_fs;..\ebox;..\Libraries\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group CMSIS
    ../Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f072xb.s startup_stm32f030xc.s
  group Libraries
    ../Libraries/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal.c stm32f0xx_hal_adc.c stm32f0xx_hal_adc_ex.c stm32f0xx_hal_can.c stm32f0xx_hal_cec.c stm32f0xx_hal_comp.c stm32f0xx_hal_cortex.c stm32f0xx_hal_crc.c stm32f0xx_hal_crc_ex.c stm32f0xx_hal_dac.c stm32f0xx_hal_dac_ex.c stm32f0xx_hal_dma.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_i2s.c stm32f0xx_hal_irda.c stm32f0xx_hal_iwdg.c stm32f0xx_hal_msp_template.c stm32f0xx_hal_pcd.c stm32f0xx_hal_pcd_ex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_rtc.c stm32f0xx_hal_rtc_ex.c stm32f0xx_hal_smartcard.c stm32f0xx_hal_smartcard_ex.c stm32f0xx_hal_smbus.c stm32f0xx_hal_spi.c stm32f0xx_hal_spi_ex.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_tsc.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_usart.c stm32f0xx_hal_wwdg.c stm32f0xx_ll_adc.c stm32f0xx_ll_comp.c stm32f0xx_ll_crc.c stm32f0xx_ll_crs.c stm32f0xx_ll_dac.c stm32f0xx_ll_dma.c stm32f0xx_ll_exti.c stm32f0xx_ll_gpio.c stm32f0xx_ll_i2c.c stm32f0xx_ll_pwr.c stm32f0xx_ll_rcc.c stm32f0xx_ll_rtc.c stm32f0xx_ll_spi.c stm32f0xx_ll_tim.c stm32f0xx_ll_usart.c stm32f0xx_ll_utils.c
  group ebox
    ../ebox/: ebox_core.cpp ebox_gpio.cpp ebox_uart.cpp ebox_it.cpp ebox_object.cpp ebox_spi.cpp ebox_soft_spi.cpp ebox_soft_iic.cpp ebox_i2c.cpp ebox_gtime.cpp ebox_pwm.cpp ebox_iflash.cpp
  group edriver
    ../edriver/: Button.cpp dht11.cpp 74HC595.cpp
  group User
    ../User/: main.cpp system_stm32f0xx.c
software components: CMSIS:CORE 4.1.0
